## configs/cf2_defconfig
```kconfig
CONFIG_PLATFORM_CF2=y
CONFIG_DECK_RPM=y
CONFIG_DECK_FORCE="bcRpm"
CONFIG_ENABLE_THRUST_BAT_COMPENSATED=n
```
